# IAR project Backup of test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: Source\CommonSource\Coinsolve; Source\CommonSource\DistanceMeter; Source\CommonSource\Door; Source\CommonSource\ExitButton; Source\CommonSource\ExternalSignal; Source\CommonSource\Motor; Source\CommonSource\SysLed; Source\CommonSource\SysTick; Source\HW; Source\HW\STM32F10x_StdPeriph_Driver; Source\HW\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TurnStyle.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Source
    Source/: main.c
  group Source/CommonSource/Coinsolve
    Source/CommonSource/Coinsolve/: Coinsolve.c Coinsolve.h
  group Source/CommonSource/DistanceMeter
    Source/CommonSource/DistanceMeter/: DistanceMeter.c DistanceMeter.h
  group Source/CommonSource/Door
    Source/CommonSource/Door/: Door.c Door.h
  group Source/CommonSource/ExitButton
    Source/CommonSource/ExitButton/: ExitButton.c ExitButton.h
  group Source/CommonSource/ExternalSignal
    Source/CommonSource/ExternalSignal/: ExternalSignal.c ExternalSignal.h
  group Source/CommonSource/Motor
    Source/CommonSource/Motor/: Motor.c Motor.h
  group Source/CommonSource/SysLed
    Source/CommonSource/SysLed/: SysLed.c SysLed.h
  group Source/CommonSource/SysTick
    Source/CommonSource/SysTick/: SysTick.c SysTick.h
  group Source/HW
    Source/HW/: hal_Types.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Source/HW/StdPeriphLib/inc
    Source/HW/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_rtc.h
  group Source/HW/StdPeriphLib/src
    Source/HW/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c
